Commit message: Imported upstream version '4.23.0' of 'upstream'

File: ros2_control_test_assets/urdf/test_hardware_components.urdf (robot description, URDF)
Before this commit: robot MinimalRobot, 3 links, 4 joints
Links:
- added link tool_link
- added link world
