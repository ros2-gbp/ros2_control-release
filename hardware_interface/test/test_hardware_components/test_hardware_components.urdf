Commit message: Imported upstream version '2.47.0' of 'upstream'

File: hardware_interface/test/test_hardware_components/test_hardware_components.urdf (robot description, URDF)
Before this commit: robot MinimalRobot, 5 links, 4 joints
Links:
- removed link tool_link
- removed link world
